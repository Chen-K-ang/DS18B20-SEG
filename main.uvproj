# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\HARDWARE\ds18b20;.\HARDWARE\smg;.\PUBLIC
  group Source Group 1
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
  group HARDWARE
    ./HARDWARE/ds18b20/: ds18b20.c
    ./HARDWARE/smg/: smg.c
  group PUBLIC
    ./PUBLIC/: public.c
